Commit message: add project4_intpol package

File: project4_intpol/urdf/manip.urdf (robot description, URDF)
Before this commit: robot manipulator, 5 links, 4 joints
Joints:
- joint tool_joint: type prismatic -> fixed
